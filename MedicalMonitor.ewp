# IAR project MedicalMonitor.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S8962 TexasInstruments LM3S8962
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: ewarm; PART_LM3S8962
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; FreeRTOS; FFT; C:\FreeRTOSv9.0.0\FreeRTOS\Source\include; C:\StellarisWare\third_party\FreeRTOS\Demo\Common\ethernet\FreeRTOS-uIP; C:\StellarisWare\boards\ek-lm3s8962; C:\FreeRTOSv9.0.0\FreeRTOS\Demo\CORTEX_LM3Sxxxx_IAR_Keil\webserver; C:\StellarisWare
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: C:\StellarisWare; C:\StellarisWare\boards\ek-lm3s8962
  OBJCOPY.OOCOutputFile: MedicalMonitor.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Libraries
    ../../../../../../StellarisWare/driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
    FFT/: optfft.c optfft.h tables.c
    ../../../../../../StellarisWare/boards/ek-lm3s8962/drivers/: rit128x96x4.c
  group Scheduler files
    FreeRTOS/: heap_2.c list.c port.c portasm.s portmacro.h queue.c tasks.c timers.c
  group Source
    Medical Monitoring/: Data.c Data.h Globals.c Globals.h Interrupts.c Interrupts.h Main.c startup_ewarm.c TaskAlert.c TaskCommand.c TaskCommnicate.c TaskCompute.c TaskDisplay.c TaskEKGCapture.c TaskEKGProcess.c TaskKeypad.c TaskMeasure.c TaskSchedule.c TaskStartup.c TaskStatus.c
